# Keil uVision project RT-Thread.uvprojx, settings and files
target RT-Thread (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LLD002 +hex
  AfterMake: fromelf  --bin --bincombined --bincombined_padding=1,0xff --output=./Objects/LLD002.bin  ./Objects/LLD002.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD,DEBUG,CLLD_DEBUG,PLLD_DEBUG
  c include: ..\Code\Libraries\CMSIS\startup;..\Code\Libraries\CMSIS;..\Code\Libraries\FWlib\inc;..\Code\BSP;..\Code\User;..\Code\App;..\Code\Motor;..\Code\RT-Thread Nano\3.1.5\components\finsh;..\Code\RT-Thread Nano\3.1.5\include;..\Code\RT-Thread Nano\3.1.5\include\libc;..\Code\Motor\TMC;..\Code\Motor\TMC\TMC5130;..\Code\Motor\Comm;..\Code\Motor\App
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Code/Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Code/Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../Code/Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group BSP
    ../Code/BSP/: include.h bsp_lib.c bsp_misc.c bsp_sysclk.c bsp_adc.c bsp_can.c bsp_iwdg.c bsp_iic.c bsp_i2c_gpio.c bsp_timer.c bsp_spi.c bsp_usart.c bsp_gpio.c bsp_flash.c
  group User
    ../Code/User/: main.c board.c rtconfig.h stm32f10x_conf.h stm32f10x_it.c
  group App
    ../Code/App/: app.c liquid_level.c app_misc.c monitor_can.c storage.c gpio.c lld_param.c
  group Motor
    ../Code/Motor/: project_config.h m95xxx.c
    ../Code/Motor/Comm/: public.c crc.c eeprom.c event.c log.c
    ../Code/Motor/TMC/: TMC_Api.c TMC_Process.c
    ../Code/Motor/TMC/TMC5130/: TMC5130.c
    ../Code/Motor/App/: msg_handle.c param.c process.c
  group rtt/source
    ../Code/RT-Thread Nano/3.1.5/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group rtt/ports
    ../Code/RT-Thread Nano/3.1.5/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
